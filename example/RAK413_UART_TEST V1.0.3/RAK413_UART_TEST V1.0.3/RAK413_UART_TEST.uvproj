# Keil uVision project RAK413_UART_TEST.uvproj, settings and files
target RAK413_UART_TEST (ARM-ADS)
  device: M058LBN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: RAK413_UART_TEST
  c flags: wLevel=2
  c include: ..\LibM051Series\StdDriver\inc;..\LibM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;.\Source;..\RAK_Inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\output\RAK410_UART_TEST.sct
  group Source
    ./Source/: USER_APP_Task.c BSP_Driver.c BSP_Init.c RAK_WIFI_Driver.c
  group CMSIS
    ../LibM051Series/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
    ../LibM051Series/StdDriver/src/: retarget.c
    ../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/iar/: startup_M051Series.s
  group API Lib
    ../RAK_Driver/: rak_config_init.c rak_connect_ap.c rak_creat_apadhoc.c rak_open_socket.c rak_query_con_status.c rak_query_dns.c rak_query_fwversion.c rak_query_ipconfig.c rak_query_rssi.c rak_scan_ap.c rak_send_data.c rak_set_channel.c rak_set_ipdhcp.c rak_set_ipstatic.c rak_set_psk.c rak_set_pwrmode.c rak_easyconfig.c rak_storeconfig.c rak_get_storeconfig.c rak_set_webconfig.c rak_start_webconfig.c rak_start_autoconnect.c rak_wake_up.c rak_wps.c rak_get_scanaps.c rak_close_socket.c rak_ltcp_status.c rak_http_get.c rak_http_post.c
